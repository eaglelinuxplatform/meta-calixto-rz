require recipes-graphics/images/core-image-weston.bb

