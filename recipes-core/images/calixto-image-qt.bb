require dynamic-layers/qt5-layer/images/core-image-qt.bb
