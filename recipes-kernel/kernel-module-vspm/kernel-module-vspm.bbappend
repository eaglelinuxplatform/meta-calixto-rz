DEPENDS += "linux-calixto"

DEPENDS_remove = "linux-renesas"
